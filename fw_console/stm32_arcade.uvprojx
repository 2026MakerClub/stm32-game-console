# Keil uVision project stm32_arcade.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_arcade
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\GLCD;.\User_common;.\SPI_touch;.\PWR_group;.\App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./User_common/: HardwareSystem_Ini.c user_defined.c
  group GLCD
    ./GLCD/: stm324xg_lcd_ILI9341_Pro.c stm32f4xx_fsmc.c
  group SPI_touch
    ./SPI_touch/: touch_module.c Driver_SPI.c
  group App
    ./App/: app_main.c menu.c ui.c gfx.c input.c sound.c game_dino.c game_2048.c game_gate.c iotest.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
